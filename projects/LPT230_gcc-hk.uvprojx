# Keil uVision project LPT230_gcc-hk.uvprojx, settings and files
target LPT230 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: lpt230_gcc
  AfterMake: ../tools/arm-none-eabi-objcopy -O binary ./lpt230_gcc.elf ./lpt230_gcc.bin
  AfterMake: ../tools/LPB100_IMG_Tools.exe LPB230 lzma  ../tools/bootloader.bin lpt230_gcc.bin ./lpt230_gcc_image.bin ./lpt230_gcc_upgrade.bin
  group src
    ../sdk/4.14/libs/: startup_LPBX3GCC.S
    ../src/: app_main.c app_main.h user_function.c user_function.h user_gpio.c user_gpio.h user_rtc.c user_rtc.h user_mqtt.c user_mqtt.h user_httpd.c user_httpd.h user_config.c user_config.h user_bl0937.c user_bl0937.h user_web.c user_web.h
  group homekit
    ../src/homekit/: hk_sha512.c hk_kdf.c hk_gf.c hk_chachapoly.c hk_curve25519.c hk_ed25519.c hk_bignum.c hk_srp.c hk_tlv.c hk_pair.c hk_json.c hk_acc.c hk_hap.c hk_store.c hk_net.c hk_code.c
  group libs
    ../src/cJSON/: cJSON.c cJSON.h
